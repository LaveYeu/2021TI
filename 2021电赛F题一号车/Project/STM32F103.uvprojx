# Keil uVision project STM32F103.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\Code\pid;..\Code\systick;..\Code\systime;..\Code\loop;..\Code\led;..\Code\key;..\Code\usart;..\Code\pwm;..\Code\encoder;..\Code\oled;..\Code\mpu;..\Code\dmp;..\Code\trx;..\Code\sys;..\Code\colorsensor;..\Code\VL53L0X\core\inc;..\Code\VL53L0X\demo;..\Code\VL53L0X\platform\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c headfile.h
  group DOC
    ../Doc/: readme.txt
  group CODE
    ../Code/pid/: pid.c
    ../Code/systick/: systick.c
    ../Code/systime/: systime.c
    ../Code/loop/: loop.c
    ../Code/led/: led.c
    ../Code/key/: key.c
    ../Code/usart/: usart.c usart1.c
    ../Code/trx/: trx.c
    ../Code/pwm/: pwm.c
    ../Code/oled/: oled.c
    ../Code/mpu/: mpu_i2c.c mpu6050.c
    ../Code/dmp/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Code/colorsensor/: TCS34725.c TCS34725111.c
    ../Code/sys/: sys.c
    ../Code/VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ../Code/VL53L0X/demo/: vl53l0x.c vl53l0x_it.c vl53l0x_gen.c
    ../Code/VL53L0X/platform/src/: vl53l0x_i2c.c vl53l0x_platform.c
