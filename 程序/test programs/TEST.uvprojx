# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\Application;.\CMSIS;.\FWLIB\inc;.\SYSTEM\sys;.\SYSTEM\delay;.\SYSTEM\linewalking;.\SYSTEM\sys;.\SYSTEM\motor;.\SYSTEM\GPIO;.\SYSTEM\PWM;.\SYSTEM\encoder;.\SYSTEM\PID;.\SYSTEM\Control;.\SYSTEM\PID_Motor
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ./CMSIS/startup/: startup_stm32f10x_md.s
  group Application
    ./Application/: main.c stm32f10x_it.c system_stm32f10x.c
  group CMSIS
    ./CMSIS/: core_cm3.c
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/linewalking/: linewalking.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/motor/: motor.c
    ./SYSTEM/GPIO/: GPIO.c
    ./SYSTEM/PWM/: pwm.c
    ./SYSTEM/encoder/: encoder.c
    ./SYSTEM/PID/: PID.c
    ./SYSTEM/PID_Motor/: PID_Motor.c
